options:
  parameters:
    generate_options: qt_gui
    id: mpsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Fc
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: M
  id: variable
  parameters:
    value: '8'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Nb
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Nb
  states: {}
- name: Sps
  id: variable
  parameters:
    value: len(h)
  states: {}
- name: h
  id: variable
  parameters:
    value: (1.,1.,1.,1.,1.,1.,1.,1,1.,1.,1.,1.,1.,1.,1.,1,1.,1.,1.,1.,1.,1.,1.,1,1.,1.,1.,1.,1.,1.,1.,1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=1024):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    A: '1'
    M: M
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  
          """
          M-PSK Modulator:
          - Output 0: envolvente compleja (1 sample/symbol)
          - Output 1: RF real (bien muestreada)
          """

          def __init__(self, M=4, A=1.0, fc=32000, fs=256000, sps=8):  
              gr.sync_block.__init__(
                  self,
                  name='MPSK_Modulator',
                  in_sig=[np.int8],
                  out_sig=[np.complex64, np.float32]
              )
              
              self.M = M
              self.A = A
              self.fc = fc
              self.fs = fs
              self.sps = sps  # samples per symbol
              
              self.k = int(np.log2(M))
              self.n_m = 0  # contador global de muestras RF

          def work(self, input_items, output_items):
              bits = input_items[0]
              bb_out = output_items[0]
              rf_out = output_items[1]

              N = len(bits)
              num_symbols = N // self.k

              if num_symbols == 0:
                  return 0

              bits = bits[:num_symbols * self.k]
              bits_reshaped = bits.reshape((num_symbols, self.k))

              # 🔹 bits → símbolos
              symbols = np.zeros(num_symbols, dtype=np.int32)
              for i in range(self.k):
                  symbols += bits_reshaped[:, i] << (self.k - i - 1)

              # 🔹 fases
              phases = 2 * np.pi * symbols / self.M

              # 🔹 envolvente compleja (NO tocar esto)
              bb = self.A * np.exp(1j * phases)

              # 🔹 generar RF correctamente
              total_samples = num_symbols * self.sps
              n = np.arange(self.n_m, self.n_m + total_samples)
              self.n_m += total_samples

              # expandir fases PERO alineadas con muestras RF
              phases_expanded = np.repeat(phases, self.sps)

              rf = self.A * np.cos(2 * np.pi * self.fc * n / self.fs + phases_expanded)

              # 🔹 salidas
              out_len = min(len(rf_out), total_samples, len(bb_out))

              bb_out[:num_symbols] = bb[:num_symbols]
              rf_out[:out_len] = rf[:out_len]

              return out_len
    fc: Fc
    fs: samp_rate
    sps: Sps
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Menu@1
    label1: Real part
    label2: Imaginary part
    marker1: '0'
    marker2: '0'
    size: int(32/Nb)
    srate: Rs
    stemplot: 'True'
    style1: '2'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    gui_hint: Menu@0
    label1: Interpolated Real part
    label2: Interpolated Imaginary part
    size: int(32*Sps/Nb)
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Menu@1
    label1: RF
    size: int(32*Sps/Nb)
    srate: Fc
    type: float
    update_time: '1'
    width1: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: Menu@0:3,0,1,1
    label1: p4
    name: '"PSD (Watts/Hz)"'
    vlen: N
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"Watss/Hz"'
    ymax: 1/Rb
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', epy_block_0_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_0_0, '0', blocks_add_xx_0, '0']
- [epy_block_0_0, '1', qtgui_time_sink_x_0_1_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
