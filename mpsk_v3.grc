options:
  parameters:
    generate_options: qt_gui
    id: mpsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '16'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Nb
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Nb
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    num_tabs: '2'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=1024):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    A: '1'
    M: M
    Rs: Rs
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.interp_block):  
          """
          M-PSK Modulator con interpolación correcta

          Input: bits (float)
          Output:
              0: baseband complejo
              1: RF real
          """

          def __init__(self, M=4, A=1.0, fc=1000, fs=32000, Rs=1000):  
              
              self.k = int(np.log2(M))      # bits por símbolo
              self.Ns = int(fs / Rs)        # samples por símbolo
              self.interp = self.Ns // self.k  # factor de interpolación
              
              gr.interp_block.__init__(
                  self,
                  name='MPSK_Modulator',
                  in_sig=[np.float32],
                  out_sig=[np.complex64, np.float32],
                  interp=self.interp
              )
              
              self.M = M
              self.A = A
              self.fc = fc
              self.fs = fs
              
              self.n_m = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              bb_out = output_items[0]
              rf_out = output_items[1]

              # float → bits
              bits = (x > 0.5).astype(np.int8)

              N = len(bits)
              num_symbols = N // self.k

              if num_symbols == 0:
                  return 0

              bits = bits[:num_symbols * self.k]
              bits_reshaped = bits.reshape((num_symbols, self.k))

              # bits → símbolos
              symbols = np.zeros(num_symbols, dtype=np.int32)
              for i in range(self.k):
                  symbols += bits_reshaped[:, i] << (self.k - i - 1)

              # fases
              phases = 2 * np.pi * symbols / self.M + math.pi / 16

              # expandir
              phases_up = np.repeat(phases, self.Ns)

              # baseband
              bb = self.A * np.exp(1j * phases_up)

              # tiempo continuo
              N_out = len(bb)
              n = np.arange(self.n_m, self.n_m + N_out)
              self.n_m += N_out

              # RF
              rf = self.A * np.cos(2 * np.pi * self.fc * n / self.fs + phases_up)

              # salida
              bb_out[:N_out] = bb
              rf_out[:N_out] = rf

              return N
    fc: '12400'
    fs: samp_rate
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@0
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Menu@1
    label1: Real part
    label2: Imaginary part
    marker1: '0'
    marker2: '0'
    size: int(32/Nb)
    srate: Rs
    stemplot: 'True'
    style1: '2'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    grid: 'True'
    gui_hint: Menu@0
    label1: Interpolated Real part
    label2: Interpolated Imaginary part
    size: int(32*Sps/Nb)
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Menu@1
    label1: RF
    size: int(32*Sps/Nb)
    srate: samp_rate
    type: float
    width1: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: Menu@0:3,0,1,1
    label1: p4
    name: '"PSD (Watts/Hz)"'
    vlen: N
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"Watss/Hz"'
    ymax: 1/Rb
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_0_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [epy_block_0_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, '1', qtgui_time_sink_x_0_1_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
